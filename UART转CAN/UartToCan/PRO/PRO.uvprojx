# Keil uVision project PRO.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PRO +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\USER;..\Driver;..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\NXP\LPC17xx;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group USER
    ../USER/: main.c sys.c
  group APP
    ../APP/: app_use.c app_can.c
  group Driver
    ../Driver/: CAN.c ADC.c LED.c GLCD_LPC1700.c uart.c delay.c
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
  group STARTCODE
    ../STARTCODE/: startup_LPC17xx.s
software components: CMSIS:CORE 5.0.1
