# Keil uVision project L50T-TEST.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: L50T-TEST +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,
  c misc: --c99
  c include: ..\CMSIS;..\FWlib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\BSP;..\Ethernet;..\Ethernet\W5500
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c stm32f10x_it.c
  group SYS
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group BSP
    ../BSP/: bsp.c bsp_can.c bsp_spi.c bsp_led.c bsp_mfu.c bsp_time.c bsp_key.c bsp_net.c
  group Ethernet
    ../Ethernet/: socket.c wizchip_conf.c
    ../Ethernet/W5500/: w5500.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_can.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c
  group CMSIS
    ../CMSIS/CoreSupport/: core_cm3.c
    ../CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group STARTCODE
    ../STARTCODE/: startup_stm32f10x_md.s
software components: CMSIS:CORE 5.0.0
